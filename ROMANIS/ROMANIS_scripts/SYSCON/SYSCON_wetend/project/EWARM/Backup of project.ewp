# IAR project Backup of project.ewp, settings and files
configuration Flash (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tptnnl8n.h
  General.OGChipSelectEditMenu: STR912 ST STR912
  ICCARM.CCIncludePath2: ..; ..\..\library\inc
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: lnkarm_flash.xcl
configuration RAM (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpannl8n.h
  XLINK.XclFile: lnkarm_ram.xcl
  group (top)
    ../: 91x_it.c main.c
  group Library
    ../../library/src/: 91x_adc.c 91x_ahbapb.c 91x_can.c 91x_dma.c 91x_emi.c 91x_fmi.c 91x_gpio.c 91x_i2c.c 91x_lib.c 91x_mc.c 91x_rtc.c 91x_scu.c 91x_ssp.c 91x_tim.c 91x_uart.c 91x_vic.c 91x_wdg.c 91x_wiu.c
  group startup
    ./: 91x_init.s 91x_vect.s
