# IAR project project.ewp, settings and files
configuration Flash (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STR912F ST STR912F
  ICCARM.CCIncludePath2: ..; ..\..\library\inc; ..\..\ENETLib\library\inc
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: project.srec
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: C:\SourceFiles\TimestampMCU\project\STR91x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration RAM (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpannl8n.h
  ICCARM.CCIncludePath2: ..; ..\..\library\inc
  ICCARM.CCOptLevel: 1
  group (top)
    ../: 91x_it.c ether.c ether.h main.c
  group ENETLib
    ../../ENETLib/library/src/: 91x_enet.c
    ../../ENETLib/library/asm/EWARM/: memcopy.s
  group Library
    ../../library/src/: 91x_adc.c 91x_ahbapb.c 91x_can.c 91x_dma.c 91x_emi.c 91x_fmi.c 91x_gpio.c 91x_i2c.c 91x_lib.c 91x_mc.c 91x_rtc.c 91x_scu.c 91x_ssp.c 91x_tim.c 91x_uart.c 91x_vic.c 91x_wdg.c 91x_wiu.c
  group startup
    ./: 91x_init.s 91x_vect.s
